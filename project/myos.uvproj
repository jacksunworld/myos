# Keil uVision project myos.uvproj, settings and files
target myos (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: myos +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin  --output ..\flashout\myos.bin ..\flashout\myos.axf
  c flags: Optim=1
  c include: ..\lib\inc;..\bsp;..\app;..\inc;..\myos\port;..\myos\myos
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group startup
    ../startup/: STM32F10x.s
  group myos
    ../myos/myos/: main.c os_task.c os_core.c
  group lib
    ../lib/src/: stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_systick.c cortexm3_macro.s
  group bsp
    ../bsp/: bsp.c
  group port
    ../myos/port/: cpu.c cpu_a.asm
